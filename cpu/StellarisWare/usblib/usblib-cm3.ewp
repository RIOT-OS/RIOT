# IAR project usblib-cm3.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S101 TexasInstruments LM3S101
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: usblib-cm3.srec
  ILINK.IlinkOutputFile: usblib-cm3.out
  group Source
    ./: usbbuffer.c usbdesc.c usbkeyboardmap.c usbmode.c usbringbuf.c usbtick.c
    device/: usbdaudio.c usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbddfu-rt.c usbdenum.c usbdhandler.c usbdhid.c usbdhidkeyb.c usbdhidmouse.c usbdmsc.c
    host/: usbhaudio.c usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhhub.c usbhmsc.c usbhostenum.c usbhscsi.c
