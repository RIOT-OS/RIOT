# Keil uVision project arm_cortexM4lf_convolution_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: arm_cortexM4lf_convolution_example
  group Source Group 1
    ../: arm_convolution_example_f32.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../../Common/GCC/: startup_ARMCM4.S
    ../../Common/: system_ARMCM4.c
