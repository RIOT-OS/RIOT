# Keil uVision project arm_cortexM3l_convolution_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: arm_cortexM3l_convolution_example
  group Source Group 1
    ../: arm_convolution_example_f32.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../../Common/G++/: startup_ARMCM3.s
    ../../Common/: system_ARMCM3.c
