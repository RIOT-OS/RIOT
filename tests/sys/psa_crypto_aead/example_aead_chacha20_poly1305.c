/*
 * SPDX-FileCopyrightText: 2025 TU Dresden
 * SPDX-License-Identifier: LGPL-2.1-only
 */

/**
 * @ingroup tests
 * @{
 *
 * @brief   Example functions for Chacha20Poly1305 Encryption and Decryption with PSA Crypto
 *
 * @author  Oliver Fritz <oliver.fritz-default@protonmail.com>
 * @author  Sergey Kreis <sergey.kreis@mailbox.tu-dresden.de>
 *
 * @}
 */
#include <stdio.h>
#include "psa/crypto.h"

#define CHACHA20_KEY_SIZE (32)

/*
 *  Chacha20Poly1305 Authenticated Encryption with Associated Data
 *
 *  https://datatracker.ietf.org/doc/html/draft-nir-cfrg-chacha20-poly1305-06#appendix-A.5
 */
static const uint8_t KEY_CHACHA20[] = {
    0x1c, 0x92, 0x40, 0xa5, 0xeb, 0x55, 0xd3, 0x8a,
    0xf3, 0x33, 0x88, 0x86, 0x04, 0xf6, 0xb5, 0xf0,
    0x47, 0x39, 0x17, 0xc1, 0x40, 0x2b, 0x80, 0x09,
    0x9d, 0xca, 0x5c, 0xbc, 0x20, 0x70, 0x75, 0xc0
};

static const uint8_t NONCE_CHACHA20[] = {
    0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04,
    0x05, 0x06, 0x07, 0x08
};

static const uint8_t ADDITIONAL_DATA[] = {
    0xf3, 0x33, 0x88, 0x86, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x4e, 0x91
};

static uint8_t PLAINTEXT[] = {
    0x49, 0x6E, 0x74, 0x65, 0x72, 0x6E, 0x65, 0x74, 0x2D, 0x44, 0x72, 0x61, 0x66, 0x74, 0x73, 0x20,
    0x61, 0x72, 0x65, 0x20, 0x64, 0x72, 0x61, 0x66, 0x74, 0x20, 0x64, 0x6F, 0x63, 0x75, 0x6D, 0x65,
    0x6E, 0x74, 0x73, 0x20, 0x76, 0x61, 0x6C, 0x69, 0x64, 0x20, 0x66, 0x6F, 0x72, 0x20, 0x61, 0x20,
    0x6D, 0x61, 0x78, 0x69, 0x6D, 0x75, 0x6D, 0x20, 0x6F, 0x66, 0x20, 0x73, 0x69, 0x78, 0x20, 0x6D,
    0x6F, 0x6E, 0x74, 0x68, 0x73, 0x20, 0x61, 0x6E, 0x64, 0x20, 0x6D, 0x61, 0x79, 0x20, 0x62, 0x65,
    0x20, 0x75, 0x70, 0x64, 0x61, 0x74, 0x65, 0x64, 0x2C, 0x20, 0x72, 0x65, 0x70, 0x6C, 0x61, 0x63,
    0x65, 0x64, 0x2C, 0x20, 0x6F, 0x72, 0x20, 0x6F, 0x62, 0x73, 0x6F, 0x6C, 0x65, 0x74, 0x65, 0x64,
    0x20, 0x62, 0x79, 0x20, 0x6F, 0x74, 0x68, 0x65, 0x72, 0x20, 0x64, 0x6F, 0x63, 0x75, 0x6D, 0x65,
    0x6E, 0x74, 0x73, 0x20, 0x61, 0x74, 0x20, 0x61, 0x6E, 0x79, 0x20, 0x74, 0x69, 0x6D, 0x65, 0x2E,
    0x20, 0x49, 0x74, 0x20, 0x69, 0x73, 0x20, 0x69, 0x6E, 0x61, 0x70, 0x70, 0x72, 0x6F, 0x70, 0x72,
    0x69, 0x61, 0x74, 0x65, 0x20, 0x74, 0x6F, 0x20, 0x75, 0x73, 0x65, 0x20, 0x49, 0x6E, 0x74, 0x65,
    0x72, 0x6E, 0x65, 0x74, 0x2D, 0x44, 0x72, 0x61, 0x66, 0x74, 0x73, 0x20, 0x61, 0x73, 0x20, 0x72,
    0x65, 0x66, 0x65, 0x72, 0x65, 0x6E, 0x63, 0x65, 0x20, 0x6D, 0x61, 0x74, 0x65, 0x72, 0x69, 0x61,
    0x6C, 0x20, 0x6F, 0x72, 0x20, 0x74, 0x6F, 0x20, 0x63, 0x69, 0x74, 0x65, 0x20, 0x74, 0x68, 0x65,
    0x6D, 0x20, 0x6F, 0x74, 0x68, 0x65, 0x72, 0x20, 0x74, 0x68, 0x61, 0x6E, 0x20, 0x61, 0x73, 0x20,
    0x2F, 0xE2, 0x80, 0x9C, 0x77, 0x6F, 0x72, 0x6B, 0x20, 0x69, 0x6E, 0x20, 0x70, 0x72, 0x6F, 0x67,
    0x72, 0x65, 0x73, 0x73, 0x2E, 0x2F, 0xE2, 0x80, 0x9D
};

static uint8_t CIPHERTEXT[] = {
    0x64, 0xA0, 0x86, 0x15, 0x75, 0x86, 0x1A, 0xF4, 0x60, 0xF0, 0x62, 0xC7, 0x9B, 0xE6, 0x43, 0xBD,
    0x5E, 0x80, 0x5C, 0xFD, 0x34, 0x5C, 0xF3, 0x89, 0xF1, 0x08, 0x67, 0x0A, 0xC7, 0x6C, 0x8C, 0xB2,
    0x4C, 0x6C, 0xFC, 0x18, 0x75, 0x5D, 0x43, 0xEE, 0xA0, 0x9E, 0xE9, 0x4E, 0x38, 0x2D, 0x26, 0xB0,
    0xBD, 0xB7, 0xB7, 0x3C, 0x32, 0x1B, 0x01, 0x00, 0xD4, 0xF0, 0x3B, 0x7F, 0x35, 0x58, 0x94, 0xCF,
    0x33, 0x2F, 0x83, 0x0E, 0x71, 0x0B, 0x97, 0xCE, 0x98, 0xC8, 0xA8, 0x4A, 0xBD, 0x0B, 0x94, 0x81,
    0x14, 0xAD, 0x17, 0x6E, 0x00, 0x8D, 0x33, 0xBD, 0x60, 0xF9, 0x82, 0xB1, 0xFF, 0x37, 0xC8, 0x55,
    0x97, 0x97, 0xA0, 0x6E, 0xF4, 0xF0, 0xEF, 0x61, 0xC1, 0x86, 0x32, 0x4E, 0x2B, 0x35, 0x06, 0x38,
    0x36, 0x06, 0x90, 0x7B, 0x6A, 0x7C, 0x02, 0xB0, 0xF9, 0xF6, 0x15, 0x7B, 0x53, 0xC8, 0x67, 0xE4,
    0xB9, 0x16, 0x6C, 0x76, 0x7B, 0x80, 0x4D, 0x46, 0xA5, 0x9B, 0x52, 0x16, 0xCD, 0xE7, 0xA4, 0xE9,
    0x90, 0x40, 0xC5, 0xA4, 0x04, 0x33, 0x22, 0x5E, 0xE2, 0x82, 0xA1, 0xB0, 0xA0, 0x6C, 0x52, 0x3E,
    0xAF, 0x45, 0x34, 0xD7, 0xF8, 0x3F, 0xA1, 0x15, 0x5B, 0x00, 0x47, 0x71, 0x8C, 0xBC, 0x54, 0x6A,
    0x0D, 0x07, 0x2B, 0x04, 0xB3, 0x56, 0x4E, 0xEA, 0x1B, 0x42, 0x22, 0x73, 0xF5, 0x48, 0x27, 0x1A,
    0x0B, 0xB2, 0x31, 0x60, 0x53, 0xFA, 0x76, 0x99, 0x19, 0x55, 0xEB, 0xD6, 0x31, 0x59, 0x43, 0x4E,
    0xCE, 0xBB, 0x4E, 0x46, 0x6D, 0xAE, 0x5A, 0x10, 0x73, 0xA6, 0x72, 0x76, 0x27, 0x09, 0x7A, 0x10,
    0x49, 0xE6, 0x17, 0xD9, 0x1D, 0x36, 0x10, 0x94, 0xFA, 0x68, 0xF0, 0xFF, 0x77, 0x98, 0x71, 0x30,
    0x30, 0x5B, 0xEA, 0xBA, 0x2E, 0xDA, 0x04, 0xDF, 0x99, 0x7B, 0x71, 0x4D, 0x6C, 0x6F, 0x2C, 0x29,
    0xA6, 0xAD, 0x5C, 0xB4, 0x02, 0x2B, 0x02, 0x70, 0x9B
};

/**
 * @brief   Example function to perform an AEAD CHACHA20POLY1305 encryption and decryption
 *          with the PSA Crypto API.
 *
 * @return  psa_status_t
 */
psa_status_t example_aead_chacha20_poly1305(void)
{
    psa_status_t status = PSA_ERROR_DOES_NOT_EXIST;
    psa_key_id_t key_id = 0;
    psa_key_attributes_t attr = psa_key_attributes_init();
    psa_key_usage_t usage = PSA_KEY_USAGE_ENCRYPT | PSA_KEY_USAGE_DECRYPT;

    psa_algorithm_t algo = PSA_ALG_AEAD_WITH_DEFAULT_LENGTH_TAG(PSA_ALG_CHACHA20_POLY1305);
    size_t encr_output_size = PSA_AEAD_ENCRYPT_OUTPUT_SIZE(PSA_KEY_TYPE_CHACHA20,
                                                           algo, sizeof(PLAINTEXT));

    /* IoT-TODO: This needs to be hardcoded for some reason, otherwise this function
    * doesn't return despite reacing the end of it.
    * This started happing after changing chacha20poly1305.c and its corresponding
    * header to the new multipart version.
    */
    uint8_t cipher_out[sizeof(PLAINTEXT) + 16];
    uint8_t plain_out[sizeof(PLAINTEXT)];
    size_t output_len = 0;

    psa_set_key_algorithm(&attr, algo);
    psa_set_key_usage_flags(&attr, usage);
    psa_set_key_bits(&attr, 256);
    psa_set_key_type(&attr, PSA_KEY_TYPE_CHACHA20);

    status = psa_import_key(&attr, KEY_CHACHA20, CHACHA20_KEY_SIZE, &key_id);
    if (status != PSA_SUCCESS) {
        psa_destroy_key(key_id);
        puts("Import key failed");
        return status;
    }

    status = psa_aead_encrypt(key_id, algo, NONCE_CHACHA20, sizeof(NONCE_CHACHA20), ADDITIONAL_DATA, sizeof(ADDITIONAL_DATA),
                              PLAINTEXT, sizeof(PLAINTEXT), cipher_out, encr_output_size, &output_len);
    if (status != PSA_SUCCESS) {
        psa_destroy_key(key_id);
        return status;
    }

    if (memcmp(cipher_out, CIPHERTEXT, sizeof(CIPHERTEXT))) {
        psa_destroy_key(key_id);
        puts("CHACHA20POLY1305: wrong ciphertext on encryption\n");
        return -1;
    }

    status = psa_aead_decrypt(key_id, algo, NONCE_CHACHA20, sizeof(NONCE_CHACHA20), ADDITIONAL_DATA, sizeof(ADDITIONAL_DATA),
                              cipher_out, sizeof(cipher_out), plain_out, sizeof(plain_out), &output_len);
    psa_destroy_key(key_id);
    if (status == PSA_SUCCESS && memcmp(PLAINTEXT, plain_out, sizeof(plain_out))) {
        printf("CHACHA20POLY1305: wrong plaintext on decryption\n");
        return -1;
    }

    return status;
}
